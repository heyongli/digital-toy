***************** Discrete PNP Electrical Parameter ********************
* Product: SS9015
* Package: TO-92
* Low Frequency, Low Noise Amplifier
* Terminals : Emitter(1) Base(2) Collector(3)
* -------------------------------------------------------------------
*BeginSpec
*JV: Ic/Ib=10
*OA: Vce=-1
*FB: Vce=-1
*VV: Ic/Ib=10
*CB:
*EB:
*ST: Ic/Ib=10
*GB: Vce=-10
*EndSpec
*BeginTrace
*JV: 0,1,100.00E-6,.1,1,3,0,0,-1 (27)
*OA: 1,1,100.00E-6,.1,1,3,0,0,-1 (27)
*FB: 0,1,100.00E-6,.1,1,3,0,0,-1 (27)
*VV: 0,1,100.00E-6,.1,1,3,0,0,-1 (27)
*CB: 0,1,.1,50,1,3,0,0,-1 (27)
*EB: 0,1,.1,10,1,3,0,0,-1 (27)
*ST: 0,1,100.00E-6,.1,1,3,0,0,-1 (27)
*GB: 0,1,100.00E-6,.1,1,3,0,0,-1 (27)
*EndTrace
*BeginParam
*IS=28.760E-15 (10.000E-21,1.0000E-6,0)
*BF=125.50 (1,1.5000E3,0)
*NF=1 (.8,1.2000,0)
*VAF=123 (0,1.0000E3,0)
*IKF=.6041 (10.000E-3,20,0)
*ISE=4.7863E-15 (0,1,0)
*NE=1.5000 (1,2,0)
*BR=4.7900 (.1,500,0)
*NR=1 (.1,5,0)
*VAR=11.290 (0,1.0000E3,0)
*IKR=.27542 (10.000E-3,20,0)
*ISC=14.454E-15 (0,1,0)
*NC=1.5000 (1,3,0)
*NK=1.2930 (.1,5,0)
*RE=.56 (0,100.00E3,0)
*RB=200 (0,100,0)
*RC=5 (0,100.00E3,0)
*CJE=2.0000E-12 (0,1,0)
*VJE=.75 (.35,1.5000,0)
*MJE=.33 (.1,1,0)
*CJC=20.956E-12 (0,1,0)
*VJC=.51642 (.35,1.5000,0)
*MJC=.65595 (.1,1,0)
*FC=.5 (.1,1.5000,0)
*TF=837.66E-12 (0,1,0)
*XTF=10 (0,100.00E3,0)
*VTF=10 (0,100.00E3,0)
*ITF=1 (0,100.00E3,0)
*PTF=0 (0,360,0)
*TR=10.000E-9 (0,1,0)
*EG=1.1100 (.69,5,0)
*XTB=0 (0,100.00E3,0)
*XTI=3 (.1,100.00E3,0)
*EndParam
*DEVICE=SS9015,PNP
* SS9015 PNP model
* created using Model Editor release 10.5.0 on 11/27/08 at 09:05
* The Model Editor is a PSpice product.
.MODEL SS9015 PNP
+ IS=28.760E-15    BF     = 125.5                NF     = 1
+ BF=125.50                NF     = 1
+ VAF=123                VAR    = 11.29                IKF    = 0.6041
+ IKF=.6041
+ ISE=4.7863E-15
+ BR=4.7900                NR     = 1                      ISE    = 4.7863E-15
+ VAR=11.290                IKF    = 0.6041
+ IKR=.27542        NK     = 1.293                 RB     = 200
+ ISC=14.454E-15     NC     = 1.5
+ NC=1.5000
+ NK=1.2930                 RB     = 200
+ RE=.56
+ RB=200
+ RC=5                   CJC    = 2.095649E-11    VJC    = 0.5164212
+ CJE=2.0000E-12
+ CJC=20.956E-12    VJC    = 0.5164212
+ VJC=.51642
+ MJC=.65595      TF     = 8.37658E-10       XCJC   = 0.451391
+ TF=837.66E-12       XCJC   = 0.451391
+ XTF=10
+ VTF=10
+ ITF=1
+ TR=10.000E-9
