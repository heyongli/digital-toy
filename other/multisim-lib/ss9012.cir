* SS9012 PNP EPITAXIAL SILICON TRANSISTOR ELECTRICAL PARAMETERS
*---------------------------------------------------------------
* Vcbo (-40V) & Vceo (-20V)
* 1W Output Amplifier of Potable Radios in Class B Push-pull Operation.
*---------------------------------------------------------------
* MODEL PARAMETERS FROM MEASURED DATA: SS9012-GBU
*---------------------------------------------------------------
*BeginSpec
*JV: Ic/Ib=10
*OA: Vce=-1
*FB: Vce=-1
*VV: Ic/Ib=10
*CB:
*EB:
*ST: Ic/Ib=10
*GB: Vce=-10
*EndSpec
*BeginTrace
*JV: 0,1,100.00E-6,.1,1,3,0,0,-1 (27)
*OA: 1,1,100.00E-6,.1,1,3,0,0,-1 (27)
*FB: 0,1,100.00E-6,.1,1,3,0,0,-1 (27)
*VV: 0,1,100.00E-6,.1,1,3,0,0,-1 (27)
*CB: 0,1,.1,50,1,3,0,0,-1 (27)
*EB: 0,1,.1,10,1,3,0,0,-1 (27)
*ST: 0,1,100.00E-6,.1,1,3,0,0,-1 (27)
*GB: 0,1,100.00E-6,.1,1,3,0,0,-1 (27)
*EndTrace
*BeginParam
*IS=20.417E-15 (10.000E-21,1.0000E-6,0)
*BF=143.30 (1,1.5000E3,0)
*NF=1 (.8,1.2000,0)
*VAF=47.750 (0,1.0000E3,0)
*IKF=.57435 (10.000E-3,20,0)
*ISE=75.858E-15 (0,1,0)
*NE=2 (1,2,0)
*BR=14.345 (.1,500,0)
*NR=.999 (.1,5,0)
*VAR=86.140 (0,1.0000E3,0)
*IKR=.42651 (10.000E-3,20,0)
*ISC=1.5849E-15 (0,1,0)
*NC=1.0087 (1,3,0)
*NK=.5 (.1,5,0)
*RE=20.000E-3 (0,100.00E3,0)
*RB=57.500 (0,100,0)
*RC=.7426 (0,100.00E3,0)
*CJE=35.100E-12 (0,1,0)
*VJE=.866 (.35,1.5000,0)
*MJE=.411 (.1,1,0)
*CJC=19.100E-12 (0,1,0)
*VJC=.787 (.35,1.5000,0)
*MJC=.394 (.1,1,0)
*FC=.5 (.1,1.5000,0)
*TF=10.000E-9 (0,1,0)
*XTF=10 (0,100.00E3,0)
*VTF=10 (0,100.00E3,0)
*ITF=1 (0,100.00E3,0)
*PTF=0 (0,360,0)
*TR=10.000E-9 (0,1,0)
*EG=1.0885 (.69,5,0)
*XTB=1.4132 (0,100.00E3,0)
*XTI=3 (.1,100.00E3,0)
*EndParam
*DEVICE=SS9012,PNP
* SS9012 PNP model
* created using Model Editor release 10.5.0 on 11/27/08 at 09:05
* The Model Editor is a PSpice product.
.MODEL SS9012 PNP
+ IS=20.417E-15
+ BF=143.30
+ VAF=47.750
+ IKF=.57435
+ ISE=75.858E-15
+ NE=2
+ BR=14.345
+ NR=.999
+ VAR=86.140
+ IKR=.42651
+ ISC=1.5849E-15
+ NC=1.0087
+ RE=20.000E-3
+ RB=57.500
+ RC=.7426
+ CJE=35.100E-12
+ VJE=.866
+ MJE=.411
+ CJC=19.100E-12
+ VJC=.787
+ MJC=.394
+ TF=10.000E-9
+ XTF=10
+ VTF=10
+ ITF=1
+ TR=10.000E-9
+ EG=1.0885
+ XTB=1.4132
