*************** Power Discrete Bipolar Electrical Parameters ***************
** Package: TO-92
** 2W Output Amplifier of Portable Radios in Class B Push-pull Operation.
**--------------------------------------------------------------------------
*BeginSpec
*JV: Ic/Ib=10
*OA: Vce=1
*FB: Vce=1
*VV: Ic/Ib=10
*CB:
*EB:
*ST: Ic/Ib=10
*GB: Vce=10
*EndSpec
*BeginTrace
*JV: 0,1,100.00E-6,.1,1,3,0,0,-1 (27)
*OA: 1,1,100.00E-6,.1,1,3,0,0,-1 (27)
*FB: 0,1,100.00E-6,.1,1,3,0,0,-1 (27)
*VV: 0,1,100.00E-6,.1,1,3,0,0,-1 (27)
*CB: 0,1,.1,50,1,3,0,0,-1 (27)
*EB: 0,1,.1,10,1,3,0,0,-1 (27)
*ST: 0,1,100.00E-6,.1,1,3,0,0,-1 (27)
*GB: 0,1,100.00E-6,.1,1,3,0,0,-1 (27)
*EndTrace
*BeginParam
*IS=377.21E-15 (10.000E-21,1.0000E-6,0)
*BF=218.08 (1,1.5000E3,0)
*NF=1.0409 (.8,1.2000,0)
*VAF=32.091 (0,1.0000E3,0)
*IKF=.84522 (10.000E-3,20,0)
*ISE=51.722E-12 (0,1,0)
*NE=2.1279 (1,2,0)
*BR=5.4580 (.1,500,0)
*NR=1.0619 (.1,5,0)
*VAR=49.099 (0,1.0000E3,0)
*IKR=2.1979 (10.000E-3,20,0)
*ISC=51.722E-12 (0,1,0)
*NC=3.9685 (1,3,0)
*NK=.5 (.1,5,0)
*RE=841.72E-6 (0,100.00E3,0)
*RB=5.7470 (0,100,0)
*RC=.24824 (0,100.00E3,0)
*CJE=27.335E-12 (0,1,0)
*VJE=.72141 (.35,1.5000,0)
*MJE=.85 (.1,1,0)
*CJC=26.000E-12 (0,1,0)
*VJC=.4 (.35,1.5000,0)
*MJC=.36785 (.1,1,0)
*FC=.9999 (.1,1.5000,0)
*TF=643.94E-12 (0,1,0)
*XTF=1.4323 (0,100.00E3,0)
*VTF=.3448 (0,100.00E3,0)
*ITF=1.2007 (0,100.00E3,0)
*PTF=0 (0,360,0)
*TR=100.00E-9 (0,1,0)
*EG=1.0500 (.69,5,0)
*XTB=.62694 (0,100.00E3,0)
*XTI=1 (.1,100.00E3,0)
*EndParam
*DEVICE=SS8050,NPN
* SS8050 NPN model
* created using Model Editor release 10.5.0 on 11/27/08 at 09:04
* The Model Editor is a PSpice product.
.MODEL SS8050 NPN
+ IS=377.21E-15     BF=218.082          NF=1.0409        VAF=32.0909
+ BF=218.08          NF=1.0409        VAF=32.0909
+ NF=1.0409        VAF=32.0909
+ VAF=32.091
+ IKF=.84522        ISE=5.17224E-11     NE=2.12785       BR=5.45795
+ ISE=51.722E-12     NE=2.12785       BR=5.45795
+ NE=2.1279       BR=5.45795
+ BR=5.4580
+ NR=1.0619         VAR=49.0994         IKR=2.19792      ISC=5.17224E-11
+ VAR=49.099         IKR=2.19792      ISC=5.17224E-11
+ IKR=2.1979      ISC=5.17224E-11
+ ISC=51.722E-12
+ NC=3.9685         RB=5.74704          IRB=0.1          RBM=0.1
+ RE=841.72E-6     RC=0.248242         XTB=0.626944     XTI=1
+ RB=5.7470          IRB=0.1          RBM=0.1
+ RC=.24824         XTB=0.626944     XTI=1
+ CJE=27.335E-12     VJE=0.721406     MJE=0.85
+ VJE=.72141     MJE=0.85
+ MJE=.85
+ CJC=26.000E-12    VJC=0.4             MJC=0.367851     XCJC=0.1
+ VJC=.4             MJC=0.367851     XCJC=0.1
+ MJC=.36785     XCJC=0.1
+ FC=.9999          CJS=0               VJS=0.75         MJS=0.5
+ TF=643.94E-12     XTF=1.43228         VTF=0.344801     ITF=1.20072
+ XTF=1.4323         VTF=0.344801     ITF=1.20072
+ VTF=.3448     ITF=1.20072
+ ITF=1.2007
+ TR=100.00E-9           PTF=0               KF=0             AF=1
+ EG=1.0500            CJE=2.73346E-11     VJE=0.721406     MJE=0.85
+ XTB=.62694     XTI=1
+ XTI=1
