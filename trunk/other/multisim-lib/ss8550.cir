****************** PNP Epitaixial Silicon Transistor *****************************
** Product: SS8550BBU / SS8550BTA / SS8550CBU / SS8550CTA / SS8550DBU / SS8550DTA
** Package: TO-92
** Terminals: Emitter(1) Base(2) Collector(3)
**--------------------------------------------------------------------------------
*BeginSpec
*JV: Ic/Ib=10
*OA: Vce=-1
*FB: Vce=-1
*VV: Ic/Ib=10
*CB:
*EB:
*ST: Ic/Ib=10
*GB: Vce=-10
*EndSpec
*BeginTrace
*JV: 0,1,100.00E-6,.1,1,3,0,0,-1 (27)
*OA: 1,1,100.00E-6,.1,1,3,0,0,-1 (27)
*FB: 0,1,100.00E-6,.1,1,3,0,0,-1 (27)
*VV: 0,1,100.00E-6,.1,1,3,0,0,-1 (27)
*CB: 0,1,.1,50,1,3,0,0,-1 (27)
*EB: 0,1,.1,10,1,3,0,0,-1 (27)
*ST: 0,1,100.00E-6,.1,1,3,0,0,-1 (27)
*GB: 0,1,100.00E-6,.1,1,3,0,0,-1 (27)
*EndTrace
*BeginParam
*IS=117.63E-15 (10.000E-21,1.0000E-6,0)
*BF=178.21 (1,1.5000E3,0)
*NF=1 (.8,1.2000,0)
*VAF=51.250 (0,1.0000E3,0)
*IKF=3.3034 (10.000E-3,20,0)
*ISE=18.820E-15 (0,1,0)
*NE=1.5000 (1,2,0)
*BR=5 (.1,500,0)
*NR=1 (.1,5,0)
*VAR=36.681 (0,1.0000E3,0)
*IKR=10.000E-3 (10.000E-3,20,0)
*ISC=200.00E-18 (0,1,0)
*NC=1.5000 (1,3,0)
*NK=.5 (.1,5,0)
*RE=0 (0,100.00E3,0)
*RB=122 (0,100,0)
*RC=1 (0,100.00E3,0)
*CJE=99.513E-12 (0,1,0)
*VJE=.77795 (.35,1.5000,0)
*MJE=.38009 (.1,1,0)
*CJC=33.278E-12 (0,1,0)
*VJC=.65102 (.35,1.5000,0)
*MJC=.38907 (.1,1,0)
*FC=.49925 (.1,1.5000,0)
*TF=796.00E-12 (0,1,0)
*XTF=10 (0,100.00E3,0)
*VTF=10 (0,100.00E3,0)
*ITF=1 (0,100.00E3,0)
*PTF=0 (0,360,0)
*TR=10.000E-9 (0,1,0)
*EG=1.1695 (.69,5,0)
*XTB=1.6730 (0,100.00E3,0)
*XTI=3 (.1,100.00E3,0)
*EndParam
*DEVICE=SS8550,PNP
* SS8550 PNP model
* created using Model Editor release 10.5.0 on 11/27/08 at 09:04
* The Model Editor is a PSpice product.
.MODEL SS8550 PNP
+ IS=117.63E-15     BF     = 178.208         NF     = 1
+ BF=178.21         NF     = 1
+ VAF=51.250           VAR    = 36.6808         IKF    = 3.3034
+ IKF=3.3034
+ ISE=18.820E-15
+ BR=5               NR     = 1               ISE    = 1.882E-14
+ VAR=36.681         IKF    = 3.3034
+ IKR=10.000E-3            RB     = 122             RBM    = 27.073
+ ISC=200.00E-18           NC     = 1.5
+ NC=1.5000
+ RB=122             RBM    = 27.073
+ RC=1
+ CJE=99.513E-12     VJE    = 0.777949
+ VJE=.77795
+ MJE=.38009        FC     = 0.499252        CJC    = 3.32783E-11
+ CJC=33.278E-12
+ VJC=.65102        MJC    = 0.389073        TF     = 7.96E-10
+ MJC=.38907        TF     = 7.96E-10
+ FC=.49925        CJC    = 3.32783E-11
+ TF=796.00E-12
+ XTF=10
+ VTF=10
+ ITF=1
+ TR=10.000E-9
+ EG=1.1695          XTB    = 1.6730          XTI    = 3
+ XTB=1.6730          XTI    = 3
